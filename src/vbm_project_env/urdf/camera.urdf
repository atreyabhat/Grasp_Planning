Commit message: Add files via upload

File: src/vbm_project_env/urdf/camera.urdf (robot description, URDF)
Before this commit: robot camera, 4 links, 3 joints
Joints:
- joint world_to_base: origin xyz=0 0 0 rpy=0 0 0 -> (none)
